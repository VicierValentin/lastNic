OS_RELEASE_FIELDS:append = " HOME_URL MADIC_PRODUCT"
HOME_URL = "https://madic.com"
LAFON_PRODUCT = "EasyBorn"
