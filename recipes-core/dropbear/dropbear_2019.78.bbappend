FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://002-config-dropbear.patch"
